<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ws2812b_network_copy.ewp</path>
  </project>
  <batchBuild />
</workspace>
